# Keil uVision project uip.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: uip +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\dev;.\uip;.\user
